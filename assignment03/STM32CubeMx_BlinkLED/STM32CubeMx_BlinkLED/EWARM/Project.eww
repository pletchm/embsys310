<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32CubeMx_BlinkLED.ewp</path>
  </project>
  <batchBuild />
</workspace>
