<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BlinkingLED1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\MorseCode\MorseCode.ewp</path>
    </project>
    <batchBuild />
</workspace>
